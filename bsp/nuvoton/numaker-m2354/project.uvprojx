# Keil uVision project project.uvprojx, settings and files
target rtthread-m2354 (6130001::V6.13.1::.\ARMCLANG)
  device: M2354KJFAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.bin"
  AfterMake: fromelf --text -c ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: RT_USING_ARM_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;board;board\NuClockConfig;board\NuPinConfig;..\libraries\m2354\CMSIS\Include;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m23;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\libraries\m2354\Device\Nuvoton\M2354\Include;..\libraries\m2354\rtt_port;..\..\..\components\dfs\include;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\libraries\m2354\StdDriver\inc;..\libraries\nu_packages\NuUtils\inc;..\..\..\components\libc\posix\src;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\linking_scripts\m2354_flash.sct
  group Applications
    applications/: main.c mnt.c
  group board
    board/NuPinConfig/: nutool_pincfg.c
    board/NuClockConfig/: nutool_modclkcfg.c
    board/: board_dev.c
  group CPU
    ../../../libcpu/arm/common/: div0.c backtrace.c showmem.c
    ../../../libcpu/arm/cortex-m23/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/misc/: rt_drv_pwm.c pin.c
    ../../../components/drivers/pm/: pm.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: workqueue.c pipe.c waitqueue.c dataqueue.c ringbuffer.c completion.c ringblk_buf.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    ../libraries/m2354/Device/Nuvoton/M2354/Source/ARM/: startup_M2354.s
    ../libraries/m2354/Device/Nuvoton/M2354/Source/: system_M2354.c
    ../libraries/m2354/rtt_port/: drv_uart.c drv_ecap.c drv_common.c drv_epwm.c drv_crc.c drv_fmc.c drv_sdh.c drv_ui2c.c drv_i2s.c drv_i2c.c drv_gpio.c drv_softi2c.c drv_spi.c drv_qei.c drv_bpwm_capture.c drv_scuart.c drv_trng.c drv_tpwm.c drv_crypto.c drv_ebi.c drv_otg.c drv_timer.c drv_timer_capture.c drv_slcd.c drv_uuart.c drv_qspi.c drv_pdma.c drv_spii2s.c drv_usbd.c drv_usbhost.c drv_bpwm.c drv_rtc.c drv_wdt.c drv_can.c drv_epwm_capture.c drv_eadc.c drv_clk.c drv_uspi.c
  group Filesystem
    ../../../components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    ../../../src/: thread.c scheduler.c mem.c components.c clock.c kservice.c device.c object.c ipc.c timer.c irq.c signal.c idle.c mempool.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc_syms.c mem_std.c syscalls.c
    ../../../components/libc/compilers/common/: stdlib.c time.c
  group Libraries
    ../libraries/m2354/StdDriver/src/: nu_clk.c nu_lcd.c nu_uart.c nu_acmp.c nu_fvc.c nu_qspi.c nu_timer_pwm.c nu_sdh.c nu_rng.c nu_tamper.c nu_dac.c nu_spi.c nu_usci_i2c.c nu_fmc.c nu_usci_uart.c nu_rtc.c nu_ebi.c nu_epwm.c nu_wwdt.c nu_ecap.c nu_i2s.c nu_timer.c nu_eadc.c nu_usci_spi.c nu_crc.c nu_ewwdt.c nu_sys.c nu_scuart.c nu_gpio.c nu_pdma.c nu_i2c.c nu_can.c nu_dpm.c nu_sc.c nu_wdt.c nu_keystore.c nu_qei.c nu_crypto.c nu_bpwm.c nu_usbd.c nu_ewdt.c
  group POSIX
    ../../../components/libc/posix/src/: unistd.c select.c poll.c
